# IAR project STM32L-Discovery.ewp, settings and files
configuration STM32L-Discovery (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152xB ST STM32L152xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L15XXB_128K; USE_FULL_ASSERT; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\libraries\\STM32_TouchSensing_Driver\inc; ..\..\libraries\CMSIS\CM3\DeviceSupport\ST\STM32L1xx; ..\..\Utilities
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L-Discovery.hex
  ILINK.IlinkOutputFile: STM32L-DISCOVERY.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group CMSIS
    ../../libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../src/: system_stm32l1xx.c
  group Doc
    ../: Readme.txt
  group EWARM
    ../../libraries/CMSIS/CM3/DeviceSupport/ST/STM32L1xx/startup/iar/: startup_stm32l1xx_md.s
  group STM32L-Discovery
    ../../Utilities/: stm32l_discovery_lcd.c
  group STM32L1xx_StdPeriph_Driver
    ../../libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_lcd.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_syscfg.c
  group TouchSensingDriver
    ../../libraries/STM32_TouchSensing_Driver/src/: stm32_tsl_api.c stm32_tsl_multichannelkey.c stm32_tsl_services.c stm32_tsl_singlechannelkey.c stm32_tsl_timebase.c stm32l15x_tsl_ct_acquisition.c
  group User
    ../src/: discover_functions.c icc_measure.c icc_measure_Ram.c main.c stm32l1xx_it.c
